# IAR project RF Connection_toggle LED.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: CC430F5137 CC430F5137
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnkCC430F5137.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: MSP430 Generic MSP430 device
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    HAL/: cc430x613x_PMM.c cc430x613x_PMM.h RF1A.c RF1A.h RF1A2.c RF1A2.h
    ./: main.c RF_Connection.c RF_Connection.h RF_Connection2.c RF_Connection2.h
